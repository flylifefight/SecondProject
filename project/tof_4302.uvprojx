# Keil uVision project tof_4302.uvprojx, settings and files
target APP (6220000::V6.22::ARMCLANG)
  device: N32G430G8Q7 Nationstech
  pack: Nationstech.N32G430_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tof_4302 +hex
  AfterMake: fromelf --bin -o "Out\app.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: ..\src;..\bsp;..\library\n32g430_std_periph_driver\inc;..\library\CMSIS\core;..\library\CMSIS\device;..\VI4302 API\inc;..\middle
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group application
    ../src/: main.c n32g430_it.c
  group library
    ../library/n32g430_std_periph_driver/src/: misc.c n32g430_adc.c n32g430_dma.c n32g430_exti.c n32g430_flash.c n32g430_gpio.c n32g430_rcc.c n32g430_rtc.c n32g430_spi.c n32g430_tim.c n32g430_usart.c
    ../library/CMSIS/device/: system_n32g430.c
    ../library/CMSIS/device/startup/: startup_n32g430.s
  group bsp
    ../bsp/: bsp_adc.c bsp_timer.c bsp_usart.c bsp_systick.c bsp_rcc.c bsp_spi.c bsp_exti.c bsp_misc.c bsp_flash.c
  group middle
    ../middle/: mid_vi4302.c
  group VI4302 API
    ../VI4302 API/src/: User_Driver.c VI4302_Config.c VI4302_System.c fw_44_00_00_00_r01.c
